# Keil uVision project W7500x_App.uvproj, settings and files
target HTTP_Server_RESTAPI (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: W7500x_App_HTTP_Server_RESTAPI +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: w7500x_app_movebinary.bat
  c flags: Optim=4
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\..\Libraries\W7500x_stdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\WIZnet\W7500\Source\ARM;..\..\ioLibrary\Ethernet;..\..\ioLibrary\Internet\DHCP;..\..\ioLibrary\Internet\DNS;..\..\ioLibrary\MDIO;..\..\ioLibrary\Application\loopback;.\src;.\src\PlatformHandler;.\src\Callback;.\src\Configuration;.\src\HTTPServer;.\src\HTTPServer\frozen
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ../../Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group CMSIS
    ../../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group W7500_Periphs
    ../../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_adc.c W7500x_dualtimer.c W7500x_gpio.c W7500x_pwm.c W7500x_uart.c W7500x_wztoe.c W7500x_crg.c
  group ioLibrary
    ../../ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ../../ioLibrary/MDIO/: W7500x_miim.c
    ../../ioLibrary/Internet/DHCP/: dhcp.c
    ../../ioLibrary/Application/loopback/: loopback.c
    ../../ioLibrary/Internet/DNS/: dns.c
  group Callback
    ./src/Callback/: dhcp_cb.c
  group User_Main
    ./src/: main.c retarget.c W7500x_it.c W7500x_board.c
  group Configuration
    ./src/Configuration/: ConfigData.c
  group PlatformHandler
    ./src/PlatformHandler/: gpioHandler.c timerHandler.c uartHandler.c
  group HTTPServer
    ./src/HTTPServer/: httpParser_rest.c httpServer_rest.c RESTapiHandler.c
  group Frozen
    ./src/HTTPServer/frozen/: frozen.c
